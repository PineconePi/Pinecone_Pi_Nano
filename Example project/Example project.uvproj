# Keil uVision project Example project.uvproj, settings and files
target Example project (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Example project
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\device\digital tube;.\Library\device\HC_SR04;.\Library\device\MP3Player;.\Library\device\Servo;.\Library\device\WS2812B;.\Library\system\ADC;.\Library\system\delay;.\Library\system\EEPROM;.\Library\system\EXTI;.\Library\system\GPIO;.\Library\system\IIC;.\Library\system\PCA;.\Library\system\PWM;.\Library\system\SYSTEM(Important documents）;.\Library\system\TIMER;.\Library\system\UART;.\Library\system\WatchDog
  group main
    ./: main.c
  group device
    ./Library/device/digital tube/: digitaltube.c
    ./Library/device/HC_SR04/: HC_SR04.c
    ./Library/device/MP3Player/: mp3player.c
    ./Library/device/Servo/: Servo.c
    ./Library/device/WS2812B/: ws2812b.c
  group system
    ./Library/system/ADC/: ADC.c
    ./Library/system/delay/: Delay.c
    ./Library/system/EEPROM/: EEPROM.c
    ./Library/system/EXTI/: exti.c
    ./Library/system/GPIO/: gpio.c
    ./Library/system/IIC/: iic.c
    ./Library/system/PCA/: PCA.c
    ./Library/system/PWM/: PWM.c
    ./Library/system/SYSTEM(Important documents）/: system.h
    ./Library/system/TIMER/: timer.c
    ./Library/system/UART/: uart.c
    ./Library/system/WatchDog/: watchdog.c
  group readme
    ./: README.md
