# Keil uVision project STC15F2K60S2.uvproj, settings and files
target Jetson_Nano_IOT (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC15F2K60S2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Hal\Hal_Usart;..\Utils;..\Hal;..\User;..\Gizwits;..\Hal\Hal_key;..\SYSTEM;..\Lib\Delay
  group User
    ../User/: main.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Hal
    ../Hal/Hal_Usart/: hal_uart.c
    ../Hal/Hal_key/: Hal_key.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group Lib
    ../Lib/Delay/: Delay.h Delay.c
